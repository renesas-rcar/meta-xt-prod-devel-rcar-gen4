RENESAS_BSP_URL = "git://github.com/renesas-rcar/linux-bsp.git"

BRANCH = "v5.10.41/rcar-5.1.7.rc11.2"
SRCREV = "${AUTOREV}"
LINUX_VERSION = "5.10.41"
